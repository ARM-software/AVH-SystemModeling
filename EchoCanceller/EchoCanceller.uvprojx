# Keil uVision project EchoCanceller.uvprojx, settings and files
target MainApp (6160000::V6.16::ARMCLANG)
  device: SSE-300-MPS3 ARM
  pack: ARM.V2M_MPS3_SSE_300_BSP.1.2.0
  cpu: IRAM(0x00000000,0x00080000) IRAM2(0x01000000,0x00200000) XRAM(0x20000000,0x00020000) XRAM2(0x20020000,0x00020000) XRAM3(0x20040000,0x00020000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: EchoCanceller
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=6 wLevel=3
  c define: __FVP_PY ARM_DSP_CONFIG_TABLES ARM_FAST_ALLOW_TABLES ARM_FFT_ALLOW_TABLES ARM_TABLE_REALCOEF_Q15 ARM_TABLE_TWIDDLECOEF_Q15_256 ARM_TABLE_BITREVIDX_FXT_256 ARM_TABLE_TWIDDLECOEF_Q15_128 ARM_TABLE_BITREVIDX_FXT_128 ARM_ALL_FAST_TABLES ARM_MATH_LOOPUNROLL DISABLEFLOAT16
  c include: .\sources;.\VSI\include;.\audiodriver;.\speexdsp;.\speexdsp\include;.\speexdsp\include\speex;.\microspeech
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT7: RAM 0x20020000 size 0x20000
  memory RVCT8: RAM 0x20040000 size 0x20000
  memory RVCT9: RAM 0x0 size 0x80000
  memory RVCT10: RAM 0x1000000 size 0x200000
  scatter file: .\RTE\Device\SSE-300-MPS3\fvp_sse300_mps3_s.sct
  link misc: --diag_suppress 6439,6314
  group sources
    ./sources/: main.c main.h scheduleinit.c scheduler.cpp AppNodes.h custom.h retarget_stdio.c process.c
  group audiodriver
    ./audiodriver/: audio_drv.c AudioInterrupt.cpp AudioConfig.h
  group speexdsp
    ./speexdsp/: fftwrap.c fftwrap.h filterbank.c mdf.c os_support.h preprocess.c config.h os_support_custom.h arch.h _speexdsp_kiss_fft_guts.h speexdsp_kiss_fft.c speexdsp_kiss_fft.h speexdsp_kiss_fftr.c speexdsp_kiss_fftr.h
  group microspeech
    ./microspeech/micro_features/: model.cc micro_model_settings.cc
    ./microspeech/: main_functions.cc recognize_commands.cc recognize_commands.h command_responder.cc command_responder.h
    ./microspeech/nodes/: clampNode.h mfccNode.h tfliteNode.h windowNode.h
  group microfrontend
    ./microspeech/microfrontend/lib/: fft.cc fft_util.cc filterbank.c filterbank_util.c log_lut.c log_scale.c log_scale_util.c noise_reduction.c noise_reduction_util.c pcan_gain_control.c pcan_gain_control_util.c
software components: CMSIS Driver:MPC 1.0.0, CMSIS Driver:PPC 1.0.0, CMSIS Driver:SPI 1.0.0, CMSIS Driver:USART 1.0.0, CMSIS:CORE 5.5.0, CMSIS:DSP 1.10.0-dev, CMSIS:NN Lib 3.0.0, CMSIS:RTOS2:Keil RTX5 5.5.4, Data Processing:Synchronous Data Flow:Core 0.3.0-dev, Data Processing:Synchronous Data Flow:Streaming Nodes 0.3.0-dev, Device:Definition 1.1.0, Device:Startup 1.1.0, Native Driver:GPIO 1.0.0, Native Driver:IO 1.0.0, Native Driver:MPC 1.0.0, Native Driver:PPC 1.0.0, Native Driver:SPI 1.0.0, Native Driver:SysCounter 1.0.0, Native Driver:SysTimer 1.0.0, Native Driver:UART 1.0.0, Native Driver:Watch Dog 1.0.0, Compiler:Event Recorder 1.4.0, Compiler:I/O:STDOUT 1.2.0, Data Exchange:Serialization:flatbuffers 1.12.0, Data Processing:Math:gemmlowp fixed-point 1.0.0, Data Processing:Math:kissfft 1.4.5, Data Processing:Math:ruy 1.12.0, Machine Learning:TensorFlow:Kernel Utils 0.2.20210719, Machine Learning:TensorFlow:Kernel 0.2.20210719
